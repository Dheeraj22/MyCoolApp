# Keil uVision project mtb-example-psoc6-hello-world.uvprojx, settings and files
target mtb-example-psoc6-hello-world (6120000::V6.12::.\ARMCLANG)
  device: CY8C6347BZI-BLD53:Cortex-M4 Cypress
  pack: Cypress.PSoC6_DFP.1.0.0
  cpu: IRAM(0x08000000,0x48000) IROM(0x10000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mtb-example-psoc6-hello-world
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: ..\MyCoolApp;.\libs
  asm include: ..\MyCoolApp;.\libs
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x8000000 size 0x48000
  scatter file: .\libs\TARGET_CY8CKIT-062-BLE\COMPONENT_CM4\TOOLCHAIN_ARM\cy8c6xx7_cm4_dual.sct
  group Source
    ./: main.c
